# Keil uVision project DK.uvproj, settings and files
target DK (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F101RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: DK
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\inc;..\USER
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c i2c.c lcd.c deputy.c
  group FWLIB
    ../FWLIB/src/: stm32f10x_rcc.c stm32f10x_gpio.c misc.c stm32f10x_pwr.c stm32f10x_tim.c stm32f10x_usart.c
