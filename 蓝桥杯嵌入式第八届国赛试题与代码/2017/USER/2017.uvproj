# Keil uVision project 2017.uvproj, settings and files
target 2017 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 2017
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\CORE;..\FWLIB\inc;..\HARDWARE;..\USER
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_i2c.c
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/: key.c led.c lcd.c adc.c capture.c i2c.c pwm.c
